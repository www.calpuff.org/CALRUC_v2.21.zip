3D.DAT file Created from RUC hourly data
2005010100      ! Beginning Day to process (YYYYMMDDHH)
2005010123      ! Ending Day to process (YYYYMMDDHH)
1               ! Process every X hours
.\data\         ! Directory of Input RUC GRIB files
tile216_2005.m3d    ! Out CALRUC/3D.DAT files
tile216_2005.lst    ! list file name  (no space before or within filename)
0               ! Resolution of Input Data (0 - 20 km, 1 - 40 km)
0               ! Type of Input File (0 - hybrid, 1 - pressure)
0               ! Type of application (0 - analysis, 1 - forecast)
1               ! Output Format (0 - old MM5.DAT, 1 - new 3D.DAT)
1               ! Compress (0 - No, 1 - Yes)
0	        ! Selection type (0 - i,j , 1 - Lat/Lon)  
173,182         ! Range Lat/J (positive for Northern Hemisphere)
84,92           ! Range of Lon/I (negative for Western Hemisphere)
1,50            ! Vertical levels selected
5	        ! User defined shift in vertical geopotential heights