3D.DAT file Created from RUC hourly data
2006061500       ! Beginning Day to process (YYYYMMDDHH)
2006061503       ! Ending Day to process (YYYYMMDDHH)
1                ! Process every X hours
.\data\20060615\ ! Path of Input RUC GRIB Files (\ or / is the must at end)
rucp.m3d         ! Out CALRUC/3D.DAT files
calruc.lst       ! list file name  (no space before or within filename)
0                ! Resolution of Input Data (0 - 20 km, 1 - 40 km)
1                ! Type of Input File (0 - hybrid, 1 - pressure)
0                ! ** Type of application (0 - analysis, 1 - forecast)
1                ! FTP site ID (1 - ncep; 2 - NWS, 3 - ARM)
1                ! Output Format (0 - old MM5.DAT, 1 - new 3D.DAT)
1                ! Compress (0 - No, 1 - Yes)
0	         ! Selection type (0 - i,j , 1 - Lat/Lon)  
213,222          ! Range Lat/J (positive for Northern Hemisphere)
291,299          ! Range of Lon/I (negative for Western Hemisphere)
1,50             ! Vertical levels selected (50 for Hybrid, 37 for press)
5	         ! User defined shift in vertical geopotential heights
0                ! Flag to check vertical profile

-----------------------------------------------------------------

* 1) Files downloaded for runs at different inital time from NCEP 
     or NWS sites must be put in sparated directories, otherwise 
     they may be overwriten due to using same file names. 

** This flag must be set to "0" for RUC files downloaded from 
   ARM site. All RUC files there are analysis files. 
   Also note that RUC forecasts cover 12 hours for runs at
   initial hours of 00, 03, 06,... 21 UTC, and 9 hours for 
   other initial hours