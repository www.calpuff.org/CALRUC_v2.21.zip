3D.DAT file Created from RUC hourly data
2008061118 ! Beginning Day to process (YYYYMMDDHH)
2008061118 ! Ending Day to process (YYYYMMDDHH)
1          ! Process every X hours
..\Data\   ! Path of Input RUC GRIB Files (\ or / is the must at end)
test2.m3d   ! Out CALRUC/3D.DAT files
calruc.lst ! list file name  (no space before or within filename)
0          ! Resolution of Input Data (0 - 20 km, 1 - 40 km)
0          ! Type of Input File (0 - hybrid, 1 - pressure)
0          ! Type of application (0 - analysis, 1 - forecast)
3          ! FTP site ID (1 - ncep; 2 - NWS, 3 - ARM)
1          ! Output Format (0 - old MM5.DAT, 1 - new 3D.DAT)
1          ! Compress (0 - No, 1 - Yes)
0	   ! Selection type (0 - i,j , 1 - Lat/Lon)  
1,225      ! Range Lat/J (positive for Northern Hemisphere)
1,301      ! Range of Lon/I (negative for Western Hemisphere)
1,50       ! Vertical levels selected (50 for Hybrid, 37 for press)
5	   ! User defined shift in vertical geopotential heights
1          ! Flag to check vertical profile

-----------------------------------------------------------------

* 1) Files downloaded for runs at different inital time from NCEP 
     or NWS sites must be put in sparated directories, otherwise 
     they may be overwriten due to using same file names. 

** This flag must be set to "0" for RUC files downloaded from 
   ARM site. All RUC files there are analysis files. 
   Also note that RUC forecasts cover 12 hours for runs at
   initial hours of 00, 03, 06,... 21 UTC, and 9 hours for 
   other initial hours

*** Separate processing into periods for following years
  2005: Three terrain elevation for 2005 RUC grib files
  a. For periods before 2005062812: ruc20.dat
  b. 2005062812 - 2005101813:       ruc20_2.dat
  c. 2005101814 - 2005112219:       ruc20_3.dat
  d. For periods after 2005101820:  ruc20_2.dat

  2006: Two terrain elevation for 2006 RUC grib files
  a: 2006010100 - 2006071113: Same as b/d in 2005 (ruc20_2.dat)
  b: 2006071114 - 2007010123: Same as c in 2005   (ruc20_3.dat)

  2008: One terrain elevation
  a: 2008010100 - 2008061117: Same as b in 2006 (ruc20_3.dat)
  b: 2008061118 - 2009010123: ruc20_4.dat